#include "bqb_a2dp.h"
#include "common/log.h"
#include "bqb_gap.h"
#include "bqb_utils.h"
#include <acts_bluetooth/a2dp.h>
#include <acts_bluetooth/host_interface.h>
#include <os_common_api.h>

static uint8_t bqb_sbc_data44k[] = { //44.1k bitpool: 23
	0x80, 0x60, 0x00, 0x36, 0x00, 0x00, 0xba, 0x00,
	0x00, 0x00, 0x00, 0x00, 0x06, 0x9c, 0xbd, 0x23,
	0xf0, 0xf0, 0x64, 0x22, 0x00, 0x00, 0x41, 0x00,
	0x10, 0x00, 0xbc, 0x29, 0x96, 0x62, 0x74, 0x07,
	0xbc, 0xb6, 0x4d, 0xc7, 0x16, 0x77, 0xad, 0xbe,
	0x1c, 0xee, 0xe5, 0xb7, 0x73, 0xe1, 0x94, 0xb6,
	0xa4, 0x6b, 0xcb, 0x37, 0x10, 0x92, 0x97, 0x99,
	0x1a, 0xd1, 0x6f, 0x10, 0x75, 0x77, 0x38, 0xa5,
	0x72, 0x90, 0x5d, 0x1e, 0x30, 0x2e, 0xc9, 0x38,
	0x55, 0x6f, 0x69, 0x58, 0xee, 0x79, 0xed, 0x35,
	0x1d, 0xd5, 0xc7, 0xd8, 0x6b, 0x2b, 0xc9, 0x37,
	0x55, 0x77, 0x60, 0x65, 0xfa, 0x4e, 0xcb, 0xa3,
	0x9c, 0xbd, 0x23, 0x19, 0xf8, 0x64, 0x31, 0x10,
	0x00, 0x41, 0x10, 0x00, 0x00, 0xa7, 0x5b, 0xa6,
	0x7c, 0x74, 0x71, 0x72, 0xe5, 0x4e, 0xa2, 0x4e,
	0x99, 0xd1, 0xc5, 0x2d, 0xf2, 0xe6, 0x38, 0xc9,
	0x43, 0x5c, 0x27, 0x3e, 0xd6, 0x2a, 0xd6, 0xde,
	0xa0, 0xf1, 0x46, 0xda, 0xab, 0x9a, 0x2d, 0x64,
	0x59, 0x6b, 0x26, 0x29, 0x8e, 0xb5, 0x91, 0x3a,
	0x0a, 0x0d, 0x57, 0x95, 0xf8, 0xcc, 0x95, 0xf0,
	0xd7, 0x3b, 0xd8, 0x3b, 0x9a, 0x37, 0x64, 0xc7,
	0xaa, 0xe6, 0xf5, 0x1e, 0xed, 0x70, 0x9f, 0x2b,
	0x61, 0x2e, 0xe3, 0x9c, 0xbd, 0x23, 0x98, 0xf0,
	0x64, 0x23, 0x00, 0x00, 0x42, 0x01, 0x10, 0x00,
	0xe9, 0x4c, 0x34, 0xd2, 0xbc, 0x30, 0x96, 0xa9,
	0x57, 0x26, 0x2e, 0xe5, 0xba, 0xe4, 0xb1, 0x9c,
	0xf8, 0x5b, 0xd7, 0xbc, 0x70, 0xcb, 0x32, 0xe6,
	0x6c, 0xe1, 0x69, 0x1c, 0xed, 0xcb, 0xac, 0x0c,
	0x19, 0x36, 0x75, 0x47, 0x72, 0xb8, 0x0e, 0xc3,
	0x72, 0x79, 0x71, 0x54, 0x39, 0x48, 0xf2, 0xd3,
	0x14, 0x2c, 0xd5, 0x19, 0x53, 0x5c, 0x86, 0x8e,
	0x42, 0xc3, 0x57, 0x70, 0xd5, 0xa0, 0x96, 0xcd,
	0xd4, 0x34, 0x95, 0x15, 0xbb, 0x65, 0x9c, 0xbd,
	0x23, 0xab, 0xf8, 0x64, 0x32, 0x00, 0x00, 0x32,
	0x10, 0x00, 0x00, 0xbb, 0x35, 0x95, 0xd7, 0x78,
	0xaa, 0x33, 0x9a, 0xaf, 0x2d, 0x36, 0x70, 0xd6,
	0x5c, 0x98, 0xee, 0xbc, 0xbb, 0x33, 0x9d, 0xb3,
	0x77, 0x78, 0x94, 0x3e, 0x8c, 0xa3, 0x0d, 0x7b,
	0xa9, 0xdb, 0xfe, 0x51, 0x16, 0xba, 0x8c, 0x35,
	0xcf, 0x47, 0x6e, 0x29, 0x3b, 0x64, 0xcd, 0x72,
	0xe7, 0x9d, 0xe1, 0xae, 0x9b, 0x13, 0xc4, 0x27,
	0x9e, 0x25, 0x6b, 0x34, 0xfe, 0x66, 0x4a, 0xf0,
	0x21, 0xe4, 0x7d, 0x37, 0x5d, 0xbd, 0xf0, 0xc6,
	0xbb, 0x9c, 0xbd, 0x23, 0xa4, 0xf0, 0x64, 0x32,
	0x00, 0x00, 0x32, 0x10, 0x00, 0x00, 0xb0, 0xb6,
	0x25, 0x07, 0x79, 0x47, 0x43, 0xa5, 0x0e, 0xf8,
	0xe9, 0x64, 0x9d, 0xd7, 0x93, 0x10, 0x4d, 0x39,
	0x2b, 0xa1, 0xca, 0x86, 0xe5, 0x94, 0x3c, 0xaa,
	0xdf, 0x4e, 0x65, 0xce, 0x1b, 0xb5, 0xaf, 0x34,
	0x3c, 0x5e, 0xbd, 0xe5, 0xd7, 0x6f, 0x97, 0xba,
	0x3e, 0xed, 0x86, 0xf6, 0x57, 0x1e, 0x21, 0x5c,
	0xd2, 0xac, 0x43, 0x1c, 0x9a, 0x22, 0x56, 0x73,
	0x62, 0xbe, 0x31, 0x15, 0xe8, 0x23, 0xae, 0xea,
	0xef, 0x09, 0x91, 0x94, 0x9c, 0xbd, 0x23, 0x7b,
	0xf0, 0x74, 0x21, 0x00, 0x00, 0x32, 0x00, 0x00,
	0x00, 0x82, 0x66, 0x79, 0x30, 0xd0, 0x45, 0x8f,
	0x5f, 0x46, 0x0b, 0x42, 0x2b, 0x96, 0x47, 0xda,
	0x43, 0x82, 0xf8, 0xed, 0x48, 0x8b, 0x17, 0x25,
	0xad, 0x90, 0x41, 0xe1, 0xad, 0x35, 0x9a, 0x93,
	0xf1, 0xa6, 0x28, 0x32, 0x7e, 0xcc, 0xe5, 0x1d,
	0x8d, 0x87, 0x5b, 0x9c, 0xbd, 0xc5, 0x2c, 0xa4,
	0x47, 0x37, 0x5d, 0x79, 0x86, 0xe5, 0x84, 0x95,
	0x4c, 0x9c, 0x8f, 0x76, 0x8a, 0x14, 0x0e, 0x2e,
	0xca, 0x63, 0x82, 0x03, 0x7b, 0xdb, 0xc4
};

static uint8_t bqb_sbc_data48k[] = {
	0x09, 0x9C, 0xF1, 0x1D, 0xA2, 0xB8, 0x53, 0x21,
	0x23, 0x74, 0x3D, 0x12, 0xAB, 0x2B, 0x08, 0x46,
	0x6D, 0x09, 0x3C, 0x43, 0x4D, 0x99, 0x9B, 0x69,
	0xB3, 0x2C, 0xD8, 0xBF, 0x62, 0x55, 0x95, 0x58,
	0x6A, 0x06, 0xAE, 0xEF, 0x8E, 0x46, 0xC8, 0x18,
	0xA9, 0x2E, 0x1A, 0xB6, 0x69, 0x66, 0x6A, 0xBB,
	0x48, 0xD4, 0xB9, 0xD2, 0x54, 0x40, 0x6D, 0x12,
	0xC4, 0x70, 0x82, 0x8A, 0xB4, 0x9B, 0xB4, 0xB4,
	0x69, 0x61, 0x95, 0x9C, 0xF1, 0x1D, 0xA6, 0xB8,
	0x53, 0x22, 0x32, 0x9E, 0x3F, 0x0D, 0x2B, 0xEE,
	0x8A, 0x49, 0x4E, 0x2D, 0x63, 0x93, 0x0F, 0x6E,
	0x9D, 0x5A, 0x6B, 0xD0, 0xEA, 0xCF, 0xDF, 0x88,
	0xD5, 0xD7, 0x03, 0x26, 0xA8, 0xC5, 0xE2, 0x99,
	0x55, 0x6E, 0xCD, 0xC4, 0xF4, 0xE5, 0x95, 0x61,
	0x55, 0xB3, 0x8A, 0xFE, 0x51, 0x54, 0x97, 0x45,
	0x2B, 0x1A, 0xA1, 0xC5, 0x35, 0x15, 0x6B, 0xDA,
	0x56, 0x14, 0x04, 0x9D, 0x35, 0x9C, 0xF1, 0x1D,
	0x0A, 0xB8, 0x43, 0x32, 0x32, 0xA3, 0x4F, 0x0D,
	0xA3, 0xE9, 0x88, 0x4D, 0x55, 0xB6, 0xBB, 0x6A,
	0x69, 0x2A, 0xA4, 0x58, 0xA5, 0x18, 0x5B, 0x56,
	0xD7, 0x86, 0xA6, 0x6D, 0x0B, 0xA6, 0xB1, 0x07,
	0xE5, 0xB5, 0x64, 0x4B, 0x6D, 0x29, 0x62, 0x6D,
	0x55, 0x61, 0x69, 0xCD, 0x63, 0x3F, 0x95, 0xE3,
	0x59, 0xC3, 0x2E, 0x92, 0xBC, 0xA6, 0x56, 0x95,
	0x36, 0x72, 0x37, 0x2C, 0x6F, 0x0D, 0x35, 0x9C,
	0xF1, 0x1D, 0x3F, 0xB8, 0x43, 0x23, 0x22, 0x9D,
	0x4C, 0x59, 0x24, 0x31, 0x72, 0x2A, 0xDF, 0xC4,
	0x99, 0x66, 0xED, 0x5E, 0x71, 0xB4, 0x9C, 0x00,
	0x59, 0xB6, 0x9B, 0xA3, 0x4E, 0xB1, 0x45, 0xA2,
	0x95, 0x1D, 0x4E, 0xDB, 0x71, 0x56, 0x66, 0x5A,
	0x6D, 0x7D, 0xAA, 0xCE, 0x14, 0x7A, 0x95, 0x2C,
	0x41, 0x8D, 0xBA, 0x31, 0xDA, 0x76, 0xCC, 0xEE,
	0xC4, 0x92, 0x22, 0x82, 0x1B, 0x8C, 0xA3, 0xD7,
	0x2B, 0x9C, 0xF1, 0x1D, 0x25, 0xB8, 0x52, 0x12,
	0x22, 0x3D, 0x61, 0x00, 0x64, 0x49, 0x07, 0x6C,
	0x68, 0x95, 0x3D, 0x53, 0x4B, 0x59, 0xE5, 0x17,
	0xAD,
};


typedef struct
{
	struct bt_l2cap_chan_ops ops;
	struct bt_l2cap_br_chan br_chan;
	struct bt_conn* conn;
	bool auto_conn_a2dp;
	uint8_t role;
}bqb_a2dp_context_t;

static bqb_a2dp_context_t s_bqb_a2dp_ctx;

static void bqb_a2dp_acl_connected(struct bt_conn *conn, u8_t err)
{
	BT_INFO("type: %d, error: 0x%x",hostif_bt_conn_get_type(conn), err);

	if (err) {
		//hostif_bt_conn_unref(s_bqb_a2dp_ctx.conn);
		s_bqb_a2dp_ctx.conn = NULL;
	} else {
		s_bqb_a2dp_ctx.conn = conn;

		if (s_bqb_a2dp_ctx.auto_conn_a2dp) {
			hostif_bt_a2dp_connect(conn, s_bqb_a2dp_ctx.role);
		}
	}
}

static bool bqb_a2dp_acl_connect_req(bt_addr_t *peer,uint8_t *cod)
{
	BT_INFO("cod: 0x%x", *cod);
	return true;
}

static void bqb_a2dp_acl_disconnected(struct bt_conn *conn, uint8_t reason)
{
	BT_INFO("disconnected : 0x%x", reason);
	if (conn == s_bqb_a2dp_ctx.conn) {
		s_bqb_a2dp_ctx.conn = NULL;
		s_bqb_a2dp_ctx.auto_conn_a2dp = false;
	}
}

static struct bt_conn_cb s_bqb_a2dp_bt_conn_cb = {
	.connect_req = bqb_a2dp_acl_connect_req,
	.connected = bqb_a2dp_acl_connected,
	.disconnected = bqb_a2dp_acl_disconnected,
};

static int bqb_a2dp_create_conn(char* role, bool conn_a2dp)
{
	bt_addr_t addr = {0};
	if (!strcmp(role, "src")) {
		s_bqb_a2dp_ctx.role = BT_A2DP_CH_SOURCE;
	} else if (!strcmp(role, "snk")) {
		s_bqb_a2dp_ctx.role = BT_A2DP_CH_SINK;
	} else {
		BT_ERR("role is error");
		return -1;
	}
	if (s_bqb_a2dp_ctx.conn) {
		hostif_bt_a2dp_connect(s_bqb_a2dp_ctx.conn, s_bqb_a2dp_ctx.role);
	} else {
		s_bqb_a2dp_ctx.auto_conn_a2dp = conn_a2dp;

		bqb_utils_read_pts_addr(&addr);
		s_bqb_a2dp_ctx.conn = hostif_bt_conn_create_br(&addr, BT_BR_CONN_PARAM_DEFAULT);
		if (!s_bqb_a2dp_ctx.conn) {
			BT_ERR("create acl failed");
			return -1;
		}
		hostif_bt_conn_unref(s_bqb_a2dp_ctx.conn);
	}
	return 0;
}

static void bqb_a2dp_connected(struct bt_conn *conn,u8_t session_type)
{
	BT_INFO("");
}
static void bqb_a2dp_disconnected(struct bt_conn *conn,u8_t session_type)
{
	BT_INFO("");
}
static void bqb_a2dp_media_handler(struct bt_conn *conn, uint8_t *data, uint16_t len)
{
	BT_INFO("");
}

static struct bt_a2dp_app_cb s_bt_a2dp_cb = {
	.connected = bqb_a2dp_connected,
	.disconnected = bqb_a2dp_disconnected,
	.media_handler = bqb_a2dp_media_handler,
};

static void bqb_a2dp_l2cap_connected(struct bt_l2cap_chan* chan)
{
	BT_INFO("\n");
}

static void bqb_a2dp_l2cap_disconnected(struct bt_l2cap_chan* chan)
{
	BT_INFO("\n");
}

static void bqb_a2dp_l2cap_encrypt_changed(struct bt_l2cap_chan* chan, uint8_t status)
{
	BT_INFO("status: %d \n", status);
}

static void bqb_a2dp_init()
{
	memset(&s_bqb_a2dp_ctx, 0, sizeof(s_bqb_a2dp_ctx));
	hostif_bt_conn_cb_register(&s_bqb_a2dp_bt_conn_cb);
	hostif_bt_a2dp_register_cb(&s_bt_a2dp_cb);
	bqb_gap_write_scan_enable(BQB_GAP_BOTH_INQUIRY_PAGE_SCAN);
}

static int bqb_a2dp_a2dp_register_src_endpoint()
{
	static uint8_t a2dp_sbc_codec[] = {
	0x00,	/* BT_A2DP_AUDIO << 4 */
	0x00,	/* BT_A2DP_SBC */
	0xFF,	/* (SNK optional) 16000, 32000, (SNK mandatory)44100, 48000, mono, dual channel, stereo, join stereo */
	0xF7,	/* (SNK mandatory) Block length: 4/8/12/16, subbands:8, Allocation Method: SNR, Londness */
	0x23,	/* min bitpool */
#ifdef CONFIG_BT_A2DP_MAX_BITPOOL
	0x23,	/* max bitpool */
#else
	0x35,
#endif
	};

	static struct bt_a2dp_endpoint bqb_endpoint;
	bqb_endpoint.info.codec = (struct bt_a2dp_media_codec*)&a2dp_sbc_codec;

	bqb_endpoint.info.a2dp_delay_report = 0;
	bqb_endpoint.info.a2dp_cp_scms_t = 0;
	bqb_endpoint.info.ep_halt = 0;
	bqb_endpoint.info.next = NULL;
	return hostif_bt_a2dp_register_endpoint(&bqb_endpoint, BT_A2DP_AUDIO, BT_A2DP_EP_SOURCE);
}

static int bqb_a2dp_a2dp_register_sink_endpoint()
{
	static uint8_t a2dp_sbc_sink_codec[] = {
	0x00,	/* BT_A2DP_AUDIO << 4 */
	0x00,	/* BT_A2DP_SBC */
	0xFF,	/* (SNK optional) 16000, 32000, (SNK mandatory)44100, 48000, mono, dual channel, stereo, join stereo */
	0xF7,	/* (SNK mandatory) Block length: 4/8/12/16, subbands:8, Allocation Method: SNR, Londness */
	0x02,	/* min bitpool */
#ifdef CONFIG_BT_A2DP_MAX_BITPOOL
	0x23,	/* max bitpool */
#else
	0x35,
#endif
	};

	static struct bt_a2dp_endpoint bqb_endpoint;
	bqb_endpoint.info.codec = (struct bt_a2dp_media_codec*)&a2dp_sbc_sink_codec;

	bqb_endpoint.info.a2dp_delay_report = 0;
	bqb_endpoint.info.a2dp_cp_scms_t = 0;
	bqb_endpoint.info.ep_halt = 0;
	bqb_endpoint.info.next = NULL;

	return hostif_bt_a2dp_register_endpoint(&bqb_endpoint, BT_A2DP_AUDIO, BT_A2DP_EP_SINK);
}


static int bqb_a2dp_test_open()
{
	s_bqb_a2dp_ctx.ops.connected = bqb_a2dp_l2cap_connected;
	s_bqb_a2dp_ctx.ops.disconnected = bqb_a2dp_l2cap_disconnected;
	s_bqb_a2dp_ctx.ops.encrypt_change = bqb_a2dp_l2cap_encrypt_changed;

	s_bqb_a2dp_ctx.br_chan.chan.ops = &s_bqb_a2dp_ctx.ops;
	s_bqb_a2dp_ctx.br_chan.rx.mtu = CONFIG_BT_L2CAP_RX_MTU;
	s_bqb_a2dp_ctx.br_chan.tx.mtu = CONFIG_BT_L2CAP_TX_MTU;

	return bt_a2dp_open(s_bqb_a2dp_ctx.conn);
}

int bqb_a2dp_test_command_handler(int argc, char *argv[])
{
	int ret = 0;
	char* cmd = argv[1];
	if (!strcmp(cmd, "start")) {
		bqb_a2dp_init();
	} else if (!strcmp(cmd, "stop")) {

	} else if (!strcmp(cmd, "conn")) {
		if (3 > argc) {
			ret = -1;
			BT_ERR("need input the role");
		} else {
			ret = bqb_a2dp_create_conn(argv[2], true);
		}
	} else if (!strcmp(cmd, "conn_acl")) {
		bqb_gap_clean_linkkey();
		if (3 > argc) {
			ret = -1;
			BT_ERR("need input the role");
		} else {
			ret = bqb_a2dp_create_conn(argv[2], false);
		}
	} else if (!strcmp(cmd, "disconn_acl")) {
		if (s_bqb_a2dp_ctx.conn) {
			ret = hostif_bt_conn_disconnect(s_bqb_a2dp_ctx.conn, BT_HCI_ERR_REMOTE_USER_TERM_CONN);
		} else {
			ret = -1;
		}
	} else if (!strcmp(cmd, "disconn_sig")) {
		hostif_bt_a2dp_disconnect(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "regsrcep")) {
		bqb_a2dp_a2dp_register_src_endpoint();
	} else if (!strcmp(cmd, "regsnkep")) {
		bqb_a2dp_a2dp_register_sink_endpoint();
	} else if (!strcmp(cmd, "setcfg")) {
		ret = bt_a2dp_set_configuration(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "open")) {
		ret = bqb_a2dp_test_open();
	} else if (!strcmp(cmd, "start")) {
		ret = hostif_bt_a2dp_start(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "close")) {
		ret = bt_a2dp_close(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "connect")) {
		ret = hostif_bt_a2dp_connect(s_bqb_a2dp_ctx.conn, BT_A2DP_CH_SOURCE);
	} else if (!strcmp(cmd, "getcap")) {
		ret = bt_a2dp_get_capabilities(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "getallcap")) {
		ret = bt_a2dp_get_all_capabilities(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "discover")) {
		ret = bt_a2dp_discover(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "conn_audio")) {
		ret = hostif_bt_a2dp_connect(s_bqb_a2dp_ctx.conn, BT_A2DP_CH_MEDIA);
	}  else if (!strcmp(cmd, "disconn_audio")) {
		ret = hostif_bt_a2dp_disconnect(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "senddata")) {
		for (uint8_t i = 0; i < 60; i++) {
			ret = hostif_bt_a2dp_send_audio_data(s_bqb_a2dp_ctx.conn, bqb_sbc_data44k, sizeof(bqb_sbc_data44k));
			if (ret < 0) {
				SYS_LOG_ERR("send data error %d\n", ret);
			}
			k_sleep(10);
		}
	} else if (!strcmp(cmd, "senddata48")){
		for (uint8_t i = 0; i < 60; i++) {
			ret = hostif_bt_a2dp_send_audio_data(s_bqb_a2dp_ctx.conn, bqb_sbc_data48k, sizeof(bqb_sbc_data48k));
			if (ret < 0) {
				SYS_LOG_ERR("send data error %d\n", ret);
			}
			k_sleep(10);
		}
	} else if (!strcmp(cmd, "suspend")) {
		ret = hostif_bt_a2dp_suspend(s_bqb_a2dp_ctx.conn);
	} else if (!strcmp(cmd, "recfg")) {
		struct bt_a2dp_media_codec* codec = bt_a2dp_get_seted_codec(s_bqb_a2dp_ctx.conn);
		ret = bt_a2dp_reconfig(s_bqb_a2dp_ctx.conn, codec);
	} else if (!strcmp(cmd, "abort")) {
		ret = bt_a2dp_abort(s_bqb_a2dp_ctx.conn);
	}
	return 0;
}

